options:
  parameters:
    author: Niels Hendrik Fliedner
    category: Custom
    copyright: 2025 AG IAS, TH OWL
    description: Spectrum Monitor using USRP B210
    generate_options: qt_gui
    id: spectrum_monitor_b210
    output_language: python
    title: Spectrum Monitor B210
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: 3.75e9
    step: 1e6
    stop: 3.8e9
    value: 3.78e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain Normalized
    start: '0'
    step: '1e-2'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    legend: 'False'
    name: ''
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"RX Spectrum"'
    type: complex
    update_time: '0.01'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    dev_args: type=b200
    gain0: rx_gain
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0-rc1
